# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\mcu_sdk
  group Project
    ./: main.c
  group User
    ../User/LED/: LED.c
    ../User/Timer/: Timer.c
    ../User/OLED/: OLED_I2C.c
    ../User/dht11/: bsp_dht11.c
    ../User/Usart/: usart.c
    ../User/delay/: delay.c
    ../User/Key/: bsp_key.c
  group mcu_sdk
    ../mcu_sdk/: mcu_api.c protocol.c system.c
